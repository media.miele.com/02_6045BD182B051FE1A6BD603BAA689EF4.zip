Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 9ff67576-d0e1-4ade-bb27-fcc216135f88, NumberOfSaves: 1]
File name: 0001
Time: 2026-08-15T00:12:13+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12519110_EU1_KU7015D:36701510_EU1_12519110_KU7015D, (2)
In: Default
Type - Material: z_Miele_Design_CLST, z_Miele_Design_BRWS, <Unnamed>, z_Miele_Connection_Connection_Modul
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 597 mm; Height: 818 mm; Depth: 550 mm
Pset_BuildingElementProxyCommon - Reference: 36701510_EU1_12519110_KU7015D; sets with these values: 2
